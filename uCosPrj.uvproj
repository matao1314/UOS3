# Keil uVision project uCosPrj.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ucos3 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\SYSTEM\delay;.\SYSTEM\usart;.\HARDWARE\LCD;.\HARDWARE\LED;.\SoftWareLIB\BSP;.\SOFTWARELIB\uCOS-III\uC-CPU;.\SOFTWARELIB\uCOS-III\uC-LIB;.\SOFTWARELIB\uCOS-III\uCOS-III;.\SoftWareLIB\STFWLib\inc;.\SOFTWARELIB\STFWLib\Startup;.\SOFTWARELIB\STFWLib\M3;.\SOFTWARELIB\BSP;.\HARDWARE\LED;.\HARDWARE\LCD;.\HARDWARE\SD;.\FATFS\src;.\FATFS\exfuns;.\HARDWARE\SPI;.\HARDWARE\MALLOC;.\HARDWARE\TEXT;.\HARDWARE\FLASH;.\HARDWARE\VS10XX;.\HARDWARE\24CXX;.\HARDWARE\TOUCH;.\HARDWARE\KEY;.\PICDECODE;.\GUI;.\APPS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./SoftWareLIB/BSP/: bsp.c common.c
  group STFWLib
    ./SOFTWARELIB/STFWLib/SOURCE/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./SOFTWARELIB/STFWLib/M3/: core_cm3.c system_stm32f10x.c
    ./SOFTWARELIB/STFWLib/Startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/delay/: delay.c
  group uCOS-III/CPU
    ./SOFTWARELIB/uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uCOS-III/LIB
    ./SOFTWARELIB/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-III/Source
    ./SOFTWARELIB/uCOS-III/uCOS-III/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
  group DEVICE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/SD/: sdcard.c sd_fs_app.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/VS10XX/: vs10XX.c
    ./HARDWARE/MALLOC/: malloc.c
    ./HARDWARE/TEXT/: text.c fontupd.c
    ./HARDWARE/FLASH/: flash.c
    ./HARDWARE/24CXX/: i2cee.c
    ./HARDWARE/TOUCH/: touch.c
    ./HARDWARE/KEY/: key.c
  group GUI
    ./GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group PICDECODE
    ./PICDECODE/: bmp.c gif.c jpeg.c piclib.c
  group APP
    ./APPS/: picviewer.c appui.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./FATFS/src/: ff.c diskio.c
